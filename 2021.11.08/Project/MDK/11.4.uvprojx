# Keil uVision project 11.4.uvprojx, settings and files
target MM32F3277_Demo (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MM32F3277G9P MindMotion
  pack: MindMotion.MM32F3270_DFP.1.0.4
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MM32F3277
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: ENABLEFSMC
  c include: ..\CODE;..\USER\src;..\USER\inc;..\..\Libraries\seekfree_libraries\common;..\..\\Libraries\seekfree_libraries\board;..\..\Libraries\seekfree_libraries\system;..\..\Libraries\seekfree_libraries;..\..\Libraries\seekfree_peripheral;..\..\Libraries\Device\CMSIS\KEIL_Core;..\..\Libraries\Device\MM32F327x\Include;..\..\Libraries\Device\MM32F327x\HAL_Lib\Inc;..\..\App\device;..\..\App\user;..\MDK
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --keep *.o(.rti_fn.*) --keep *.o(FSymTab)
  group App
    ../../App/device/: All_Init.c All_Init.h devices.c devices.h MyFlash.c MyFlash.h ANO_DT.c ANO_DT.h Communicate.c Communicate.h app_filter.c app_filter.h
  group user_c
    ../USER/src/: isr.c main.c
    ../../App/user/: control.c cam.c display.c pid.c elc.c
  group user_h
    ../USER/inc/: isr.h
    ../../App/user/: control.h cam.h display.h pid.h elc.h
  group seekfree_peripheral
    ../../Libraries/seekfree_peripheral/: SEEKFREE_IPS114_SPI.c SEEKFREE_IPS114_SPI.h SEEKFREE_ICM20602.c SEEKFREE_ICM20602.h SEEKFREE_7725.c SEEKFREE_7725.h SEEKFREE_WIRELESS.c SEEKFREE_WIRELESS.h SEEKFREE_IIC.c SEEKFREE_IIC.h SEEKFREE_FONT.c SEEKFREE_FONT.h SEEKFREE_MT9V03X.c SEEKFREE_MT9V03X.h LQ_CAMERA.c LQ_CAMERA.h
  group seekfree_libraries
    ../../Libraries/seekfree_libraries/: headfile.h zf_adc.c zf_adc.h zf_camera.c zf_camera.h zf_exti.c zf_exti.h zf_flash.c zf_flash.h zf_gpio.c zf_gpio.h zf_pit.c zf_pit.h zf_pwm.c zf_pwm.h zf_spi.c zf_spi.h zf_systick.c zf_systick.h zf_tim.c zf_tim.h zf_uart.c zf_uart.h
  group MM32_HAL
    ../../Libraries/Device/MM32F327x/HAL_Lib/Inc/: dtype.h hal_conf.h hal_device.h hal_redefine.h hal_adc.h hal_bkp.h hal_comp.h hal_crs.h hal_dac.h hal_dbg.h hal_dma.h hal_exti.h hal_flash.h hal_gpio.h hal_i2c.h hal_iwdg.h hal_misc.h hal_pwr.h hal_rcc.h hal_sdio.h hal_spi.h hal_syscfg.h hal_tim.h hal_uart.h hal_ver.h hal_wwdg.h
    ../../Libraries/Device/MM32F327x/HAL_Lib/Src/: hal_adc.c hal_bkp.c hal_comp.c hal_crs.c hal_dac.c hal_dbg.c hal_dma.c hal_exti.c hal_flash.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_sdio.c hal_spi.c hal_tim.c hal_uart.c hal_ver.c hal_wwdg.c
  group common
    ../../Libraries/seekfree_libraries/common/: common.c common.h SEEKFREE_PRINTF.c SEEKFREE_PRINTF.h
  group board
    ../../Libraries/seekfree_libraries/board/: board.c board.h
  group doc
    ../../Libraries/doc/: pin_recommend.txt version.txt
  group startup
    ../../Libraries/Device/MM32F327x/Source/: system_mm32f327x.c
    ../../Libraries/Device/MM32F327x/Source/KEIL_StartAsm/: startup_mm32f327x_keil.s
  group README
    ./: RT-README
software components: RTOS:device 3.1.5, RTOS:kernel 3.1.5, RTOS:shell 3.1.5
